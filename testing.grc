options:
  parameters:
    generate_options: qt_gui
    id: GSM_TESTING
    output_language: python
    title: GSM TESTING
  states: {}

blocks:
- name: AGCH
  id: variable
  parameters:
    value: '4'
  states: {}
- name: BCCH
  id: variable
  parameters:
    value: '1'
  states: {}
- name: CCCH
  id: variable
  parameters:
    value: '2'
  states: {}
- name: CHANNEL_UNKNOWN
  id: variable
  parameters:
    value: '0'
  states: {}
- name: PCH
  id: variable
  parameters:
    value: '5'
  states: {}
- name: RACH
  id: variable
  parameters:
    value: '3'
  states: {}
- name: SDCCH
  id: variable
  parameters:
    value: '6'
  states: {}
- name: fc
  id: variable_qtgui_range
  parameters:
    label: center_frequency
    start: 925e6
    step: 200e3
    stop: 960e6
    value: 939e6
  states: {}
- name: g
  id: variable_qtgui_range
  parameters:
    label: gain
    start: '0'
    step: '0.5'
    stop: '50'
    value: '43'
  states: {}
- name: osr
  id: variable
  parameters:
    value: '4'
  states: {}
- name: ppm
  id: variable_qtgui_range
  parameters:
    label: clock_correction [ppm]
    start: '-150'
    step: '1'
    stop: '150'
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '100'
    freq: '939000000'
    offset: '200'
    phase: '0'
    samp_rate: samp_rate
    showports: 'True'
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: gsm_clock_offset_control_0
  id: gsm_clock_offset_control
  parameters:
    fc: fc
    osr: osr
    samp_rate: samp_rate
  states: {}
- name: gsm_control_channels_decoder_0
  id: gsm_control_channels_decoder
  parameters: {}
  states: {}
- name: gsm_input_0
  id: gsm_input
  parameters:
    samp_rate_in: samp_rate
  states: {}
- name: gsm_message_printer_0
  id: gsm_message_printer
  parameters:
    prepend_fnr: 'False'
    prepend_frame_count: 'False'
    print_gsmtap_header: 'False'
  states: {}
- name: gsm_receiver_0
  id: gsm_receiver
  parameters:
    osr: '4'
  states: {}
- name: gsm_universal_ctrl_chans_demapper_0
  id: gsm_universal_ctrl_chans_demapper
  parameters: {}
  states: {}
- name: network_socket_pdu_0
  id: network_socket_pdu
  parameters:
    host: 127.0.0.1
    mtu: '10000'
    port: '5555'
    type: TCP_SERVER
  states: {}
- name: pdu_pdu_to_stream_x_0
  id: pdu_pdu_to_stream_x
  parameters:
    early_behavior: pdu.EARLY_BURST_DROP
    type: complex
  states: {state: disabled}
- name: ppm_param
  id: parameter
  parameters:
    label: ppm
    short_id: p
    type: intx
    value: '0'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: fc
    fftsize: '1024'
    type: complex
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: fc
    gain0: '0'
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {state: disabled}
- name: zeromq_push_msg_sink_0
  id: zeromq_push_msg_sink
  parameters:
    address: '"tcp://127.0.0.1:5555"'
    timeout: '100'
  states: {state: disabled}
- name: zeromq_push_sink_0
  id: zeromq_push_sink
  parameters:
    address: '"tcp://127.0.0.1:5555"'
    timeout: '100'
    type: complex
  states: {state: disabled}

connections:
- [analog_sig_source_x_0, '0', blocks_throttle2_0, '0']
- [blocks_throttle2_0, '0', gsm_input_0, '0']
- [blocks_throttle2_0, '0', qtgui_freq_sink_x_0, '0']
- [gsm_clock_offset_control_0, ctrl, gsm_input_0, ctrl_in]
- [gsm_control_channels_decoder_0, msgs, blocks_message_debug_0, log]
- [gsm_control_channels_decoder_0, msgs, gsm_message_printer_0, msgs]
- [gsm_control_channels_decoder_0, msgs, network_socket_pdu_0, pdus]
- [gsm_control_channels_decoder_0, msgs, pdu_pdu_to_stream_x_0, pdus]
- [gsm_control_channels_decoder_0, msgs, zeromq_push_msg_sink_0, in]
- [gsm_input_0, '0', gsm_receiver_0, '0']
- [gsm_receiver_0, C0, gsm_universal_ctrl_chans_demapper_0, bursts]
- [gsm_receiver_0, measurements, gsm_clock_offset_control_0, measurements]
- [gsm_universal_ctrl_chans_demapper_0, bursts, gsm_control_channels_decoder_0, bursts]
- [network_socket_pdu_0, pdus, blocks_message_debug_0, log]
- [pdu_pdu_to_stream_x_0, '0', zeromq_push_sink_0, '0']
- [uhd_usrp_source_0, '0', gsm_input_0, '0']
- [uhd_usrp_source_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
